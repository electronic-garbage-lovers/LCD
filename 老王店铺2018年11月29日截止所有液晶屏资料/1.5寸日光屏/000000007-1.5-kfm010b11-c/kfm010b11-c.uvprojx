# Keil uVision project kfm010b11-c.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: kfm010b11-c +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS;.\UserCODE;.\UserDRV
  asm include: .\CMSIS;.\UserCODE;.\UserDRV
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group UserCode
    ./: mian.c
  group Userdrv
    ./UserDRV/: configALL.H delay.c delay.h Stm32f10xFsmc_init.c Stm32f10xFsmc_init.h Stm32f10xGPIO_INIT.c Stm32f10xGPIO_INIT.H Stm32F10xUart_init.c Stm32F10xUart_init.h SysTickInit.c SysTickInit.h gImage_test.c gImage_test.h ASCII_FONT16x8.c ASCII_FONT16x8.h GB16x16Font.c GB16x16Font.h kfm010b11.C kfm010b11.H ASCII_FONT8x8.c ASCII_FONT8x8.h ASCII_FONT_H16x8.c ASCII_FONT_H16x8.H
  group cmsis
    ./CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
