# Keil uVision project SSD1331 OLED.uvprojx, settings and files
target SSD1331 OLED (5030076::V5.03 [Build 76]::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SSD1331 OLED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,INTERFACE_SPI
  c include: ..\SRC\Hardware\SPI;..\SRC\Hardware\delay;..\SRC\Hardware\SSD1331;..\SRC\STM32F10x_LIB\CMSIS;..\SRC\STM32F10x_LIB\inc;..\SRC\USER;..\SRC\Hardware\Fonts
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Hardware
    ../SRC/Hardware/SPI/: SPI.c
    ../SRC/Hardware/SSD1331/: SSD1331.c
    ../SRC/Hardware/delay/: delay.c
    ../SRC/Hardware/Fonts/: Fonts.c
  group STM32F10x_LIB
    ../SRC/STM32F10x_LIB/CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
    ../SRC/STM32F10x_LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c
  group USER
    ../SRC/USER/: Config.c main.c stm32f10x_it.c
software components: CMSIS:CORE 5.1.2
