# Keil uVision project CSTNLCD.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CSTNLCD +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS;.\USER_DRV
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group UserCode
    ./USER_CODE/: main.c
  group UserDrv
    ./USER_DRV/: delay.c delay.h Stm32f10xGpioInit.c Stm32f10xGpioInit.h gImage_test.c gImage_test.h stm32f10x_AFIO.C stm32f10x_AFIO.H LED0.H COG_C177MVHG_03.C COG_C177MVHG_03.H ASCII_FONT_V8x8.c ASCII_FONT_V8x8.h ASCII_FONT_V8X16.c ASCII_FONT_V8X16.H
  group cmsis
    ./CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
