# Keil uVision project 1.4.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: 1.4 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\测试程序;C:\Keil\C51\INC;C:\Keil51\C51\INC;C:\Keil\C51\INC\STC
  asm include: C:\Keil\C51\INC\STC
  group Source Group 1
    ./: STARTUP.A51 main.c STC12C5A60S2.H
