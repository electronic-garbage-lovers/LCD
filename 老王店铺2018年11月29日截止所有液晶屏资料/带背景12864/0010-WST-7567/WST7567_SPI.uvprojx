# Keil uVision project WST7567_SPI.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WST7567_SPI +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS;.\USER_DRV
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group UserCode
    ./USER_CODE/: main.c
  group UserDrv
    ./USER_DRV/: delay.c delay.h Stm32f10xGpioInit.c Stm32f10xGpioInit.h WST7567.C WST7567.H gImage_test.c gImage_test.h ASCII_FONT.C ASCII_FONT.h
  group cmsis
    ./CMSIS/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
